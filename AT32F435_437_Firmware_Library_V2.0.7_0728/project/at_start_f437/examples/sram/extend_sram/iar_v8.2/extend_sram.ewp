# IAR project extend_sram.ewp, settings and files
configuration extend_sram_512k (ARM)
  General.OGChipSelectEditMenu: AT32F437ZMT7_v2 ArteryTek -AT32F437ZMT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F437ZMT7; USE_STDPERIPH_DRIVER; AT_START_F437_V1; EXTEND_SRAM=FLASH_EOPB0_SRAM_512K
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\libraries\drivers\inc; ..\..\..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\..\..\at32f435_437_board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: extend_sram_512k.hex
  ILINK.IlinkOutputFile: extend_sram_512k.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration extend_sram_448k (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: AT32F437ZMT7; USE_STDPERIPH_DRIVER; AT_START_F437_V1; EXTEND_SRAM=FLASH_EOPB0_SRAM_448K
  OBJCOPY.OOCOutputFile: extend_sram_448k.hex
configuration extend_sram_384k (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: AT32F437ZMT7; USE_STDPERIPH_DRIVER; AT_START_F437_V1; EXTEND_SRAM=FLASH_EOPB0_SRAM_384K
  OBJCOPY.OOCOutputFile: extend_sram_384k.hex
configuration extend_sram_320k (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: AT32F437ZMT7; USE_STDPERIPH_DRIVER; AT_START_F437_V1; EXTEND_SRAM=FLASH_EOPB0_SRAM_320K
  OBJCOPY.OOCOutputFile: extend_sram_320k.hex
configuration extend_sram_256k (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: AT32F437ZMT7; USE_STDPERIPH_DRIVER; AT_START_F437_V1; EXTEND_SRAM=FLASH_EOPB0_SRAM_256K
  OBJCOPY.OOCOutputFile: extend_sram_256k.hex
configuration extend_sram_192k (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: AT32F437ZMT7; USE_STDPERIPH_DRIVER; AT_START_F437_V1; EXTEND_SRAM=FLASH_EOPB0_SRAM_192K
  OBJCOPY.OOCOutputFile: extend_sram_192k.hex
configuration extend_sram_128k (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: AT32F437ZMT7; USE_STDPERIPH_DRIVER; AT_START_F437_V1; EXTEND_SRAM=FLASH_EOPB0_SRAM_128K
  OBJCOPY.OOCOutputFile: extend_sram_128k.hex
  group bsp
    ../../../../../at32f435_437_board/: at32f435_437_board.c
  group cmsis
    ./: startup_at32f435_437_ext_ram.s
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32f435_437_crm.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_misc.c at32f435_437_usart.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32f435_437_clock.c at32f435_437_int.c main.c
