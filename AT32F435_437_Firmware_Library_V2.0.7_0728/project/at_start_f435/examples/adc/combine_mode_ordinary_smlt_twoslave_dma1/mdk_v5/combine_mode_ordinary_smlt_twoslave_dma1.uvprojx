# Keil uVision project combine_mode_ordinary_smlt_twoslave_dma1.uvprojx, settings and files
target combine_mode_ordinary_smlt_twoslave_dma1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: -AT32F435ZMT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.0.8
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x3F0000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: combine_mode_ordinary_smlt_twoslave_dma1 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F435ZMT7,USE_STDPERIPH_DRIVER,AT_START_F435_V1
  c include: ..\inc;..\..\..\..\..\at32f435_437_board;..\..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\..\..\libraries\drivers\inc
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../src/: at32f435_437_clock.c at32f435_437_int.c main.c
  group bsp
    ../../../../../at32f435_437_board/: at32f435_437_board.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32f435_437_gpio.c at32f435_437_misc.c at32f435_437_crm.c at32f435_437_dma.c at32f435_437_adc.c at32f435_437_usart.c at32f435_437_tmr.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
    ../../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f435_437.s
  group readme
    ../: readme.txt
