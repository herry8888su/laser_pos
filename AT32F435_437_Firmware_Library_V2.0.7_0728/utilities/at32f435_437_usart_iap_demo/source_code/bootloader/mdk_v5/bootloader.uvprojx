# Keil uVision project bootloader.uvprojx, settings and files
target at_start_f435 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: -AT32F435ZMT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.0.8
  cpu: IROM(0x08000000,0x3F0000) IRAM(0x20000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: at32f435_bootloader +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F435ZMT7,USE_STDPERIPH_DRIVER,AT_START_F435_V1
  c include: ..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\..\..\project\at32f435_437_board
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../src/: at32f435_437_clock.c at32f435_437_int.c flash.c iap.c tmr.c usart.c main.c
  group bsp
    ../../../../../project/at32f435_437_board/: at32f435_437_board.c
  group firmware
    ../../../../../libraries/drivers/src/: at32f435_437_crm.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_usart.c at32f435_437_tmr.c at32f435_437_misc.c
  group cmsis
    ../../../../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
    ../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f435_437.s
  group readme
    ../: readme.txt
target at_start_f437 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: -AT32F437ZMT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.0.8
  cpu: as above
  output: at32f437_bootloader +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F437ZMT7,USE_STDPERIPH_DRIVER,AT_START_F437_V1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x60000
