# IAR project qspi_algorithm.ewp, settings and files
configuration qspi_algorithm (ARM)
  General.OGChipSelectEditMenu: AT32F435ZMT7_v2 ArteryTek -AT32F435ZMT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: AT32F435ZMT7
  ICCARM.CCIncludePath2: ..\inc; ..\framework2; ..\..\..\..\libraries\drivers\inc; ..\..\..\..\libraries\cmsis\cm4\device_support; ..\..\..\..\libraries\cmsis\cm4\core_support
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: qspi_algorithm.srec
  ILINK.IlinkOutputFile: qspi_algorithm.out
  ILINK.IlinkIcfFile: qspi_algorithm.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
  group (top)
    ../src/: qspi_algorithm.c
  group framework2
    ../framework2/: flash_loader.c flash_loader_asm.s
  group readme
    ../: readme.txt
