# IAR project freertos_demo.ewp, settings and files
configuration at_start_f435 (ARM, debug)
  General.OGChipSelectEditMenu: AT32F435ZMT7_v2 ArteryTek -AT32F435ZMT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT_START_F435_V1; AT32F435ZMT7
  ICCARM.CCIncludePath2: ..\..\..\libraries\drivers\inc; ..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\libraries\cmsis\cm4\device_support; ..\..\..\middlewares\freertos\source\include; ..\..\..\middlewares\freertos\source\portable\IAR\ARM_CM4F; ..\inc; ..\..\..\project\at32f435_437_board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\middlewares\freertos\source\portable\IAR\ARM_CM4F; ..\inc
  OBJCOPY.OOCOutputFile: freertos_demo.hex
  ILINK.IlinkOutputFile: freertos_demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration at_start_f437 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F437ZMT7_v2 ArteryTek -AT32F437ZMT7
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT_START_F437_V1; AT32F437ZMT7
  group bsp
    ../../../project/at32f435_437_board/: at32f435_437_board.c
  group cmsis
    ../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f435_437.s
    ../../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
  group firmware
    ../../../libraries/drivers/src/: at32f435_437_acc.c at32f435_437_adc.c at32f435_437_can.c at32f435_437_crc.c at32f435_437_crm.c at32f435_437_dac.c at32f435_437_debug.c at32f435_437_dma.c at32f435_437_dvp.c at32f435_437_edma.c at32f435_437_emac.c at32f435_437_ertc.c at32f435_437_exint.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_i2c.c at32f435_437_misc.c at32f435_437_pwc.c at32f435_437_qspi.c at32f435_437_scfg.c at32f435_437_sdio.c at32f435_437_spi.c at32f435_437_tmr.c at32f435_437_usart.c at32f435_437_usb.c at32f435_437_wdt.c at32f435_437_wwdt.c at32f435_437_xmc.c
  group freertos
    ../../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../middlewares/freertos/source/portable/memmang/: heap_4.c
    ../../../middlewares/freertos/source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group readme
    ../: readme.txt
  group user
    ../src/: at32f435_437_clock.c at32f435_437_int.c main.c
